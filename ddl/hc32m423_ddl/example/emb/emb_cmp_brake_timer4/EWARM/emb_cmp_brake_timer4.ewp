# IAR project emb_cmp_brake_timer4.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32M423; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: emb_cmp_brake_timer4.srec
  ILINK.IlinkOutputFile: emb_cmp_brake_timer4.out
  ILINK.IlinkIcfFile: hc32m423.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32M423; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../mcu/common/: system_hc32m423.c
    ./: startup_hc32m423.s
  group driver
    ../../../../driver/src/: hc32m423_gpio.c hc32m423_icg.c hc32m423_clk.c hc32m423_pwc.c hc32m423_interrupts.c hc32m423_utility.c hc32m423_timer4.c hc32m423_cmp.c hc32m423_emb.c
  group source
    ../source/: main.c
