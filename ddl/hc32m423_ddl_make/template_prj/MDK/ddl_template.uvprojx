# Keil uVision project ddl_template.uvprojx, settings and files
target {FEATURE}_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32M423KATB HDSC
  pack: HDSC.HC32M423.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ESEL ELITTLE
  output: {FEATURE}
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: __DEBUG,HC32M423,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: {SAMPLE_DEPTH}mcu\common;..\source;{SAMPLE_DEPTH}driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1FFFE000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32m423.s
    {SAMPLE_DEPTH}mcu/common/: system_hc32m423.c
  group source
    ../source/: main.c
  group Readme
    ../: Readme.txt
target {FEATURE}_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32M423KATB HDSC
  pack: HDSC.HC32M423.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFE000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ESEL ELITTLE
  output: {FEATURE} +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32M423,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: {SAMPLE_DEPTH}mcu\common;..\source;{SAMPLE_DEPTH}driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1FFFE000 size 0x4000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
