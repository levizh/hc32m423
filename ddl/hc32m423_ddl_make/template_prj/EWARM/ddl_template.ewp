# IAR project ddl_template.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32M423; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: {SAMPLE_DEPTH}mcu\common; ..\source; {SAMPLE_DEPTH}driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: {FEATURE}.srec
  ILINK.IlinkOutputFile: {FEATURE}.out
  ILINK.IlinkIcfFile: hc32m423.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32M423; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: {SAMPLE_DEPTH}mcu\common; ..\source; {SAMPLE_DEPTH}driver\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    {SAMPLE_DEPTH}mcu/common/: system_hc32m423.c
    ./: startup_hc32m423.s
  group source
    ../source/: main.c
